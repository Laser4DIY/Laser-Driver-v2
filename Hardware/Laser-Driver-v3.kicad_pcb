# Repository Laser4DIY/Laser-Driver-v2

File README.md:

# LASER4DIY Laser Diode Driver

Laser diode driver to be used for the Laser4DIY project, see http://www.laser4diy.org/

**Note: This project is work in progress!**

## Design Goals

- Continous mode: up to 80A (at 2V)
- Pulse mode: up to 80A (at 2V), pulses <50µsec possible

Copyright FabLab München e.V. 2021.

This source describes Open Hardware and is licensed under the CERN-OHL-P v2

You may redistribute and modify this documentation and make products using it 
under the terms of the CERN-OHL-P v2 (https:/cern.ch/cern-ohl).
This documentation is distributed WITHOUT ANY EXPRESS OR IMPLIED WARRANTY, 
INCLUDING OF MERCHANTABILITY, SATISFACTORY QUALITY AND FITNESS FOR A  PARTICULAR 
PURPOSE. Please see the CERN-OHL-P v2 for applicable conditions

## KiCad design Hardware/Laser-Driver-v3.kicad_pcb

Parts:
C1, C6, C9: 100nF; C_0603_1608Metric
H1, H2, H3, H4: M3; MountingHole_3.2mm_M3_Pad_Via
HS1: ATS-1139-C1-R0; ATS-1141
J1: Screw_Terminal_01x02; TerminalBlock_bornier-2_P5.08mm
J2, J5: 7460307
Q1: IRFP4568PbF; TO-247-3_Vertical
Q2: PSMN0R7-25YLD; LFPAK56
R1, R2, R8: 10k; R_0603_1608Metric
R3: 20k; R_0603_1608Metric
R4, R5, R6: 100R; R_0603_1608Metric
R7: 1 mOhms ±5% 10W; 2959_metric_15075
R37: 1M; R_0603_1608Metric
TH1: NTCALUG03A103G
U1: OPA2354AIDDA; SOIC-8-1EP_3.9x4.9mm_P1.27mm_EP2.29x3mm

Connections:
+3V3: C6.2, R1.2, U1.8 (V+); also elsewhere on the board
-3V3: U1.4 (V-); also elsewhere on the board
/Output Stage/MOSFET-OUT: Q1.1 (G); also elsewhere on the board
/Overcurrent Protection/OCMosfet: Q2.4 (G); also elsewhere on the board
/Overcurrent Protection/OCSense: R2.1; also elsewhere on the board
/Teensy/ADC-SHUNT: R3.1, U1.1 (OUTA); also elsewhere on the board
/Teensy/TempSense: C1.2, J1.2, R1.1; also elsewhere on the board
Earth: C9.2, H1.1, H2.1, H3.1, H4.1, R37.2
GND: C1.1, C6.1, C9.1, J1.1, J5.1, R5.2, R7.2, R8.2, R37.1; also elsewhere on the board
unnamed: J2.1, Q1.2 (D)
unnamed: Q1.3 (S), Q2.5 (D)
unnamed: Q2.1 (S), Q2.2 (S), Q2.3 (S), R4.1, R7.1
unnamed: R2.2, R6.1, U1.3 (+INA), U1.7 (OUTB)
unnamed: R3.2, R8.1, U1.2 (-INA)
unnamed: R4.2, U1.5 (+INB)
unnamed: R5.1, R6.2, U1.6 (-INB)
unnamed: TH1.1, TH1.2

Notes on the sheet:
Alternative for TLV3541: THS4271
OFFBOARD!!!
Heat Sink Calculations: Tj = P(Rjunc-case + Rcase-hs + Rhs) + Tamb Rjunc-case = 0.29 C/W Rcase-hs = 0.24 C/W Rhs = 3.7 C/W (changing heatsink will change this) Tj = 175 C max Tamb = 50 C max with 3.7 C/W thermal resistance heatsink, 29W can be dissipated in the transistor. with 4.8mOhm typ Rds of t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

Parts:
C15: 10nF; C_0603_1608Metric
C16: 1uF; C_0603_1608Metric
R9, R35: 0R; R_0603_1608Metric
U2: Teensy4.0; Teensy40_SMT
U3: ADS7883SBDBVR; TSOT-23-6

Connections:
+3V3: C15.2, C16.2, U2.16 (3V3), U2.31 (3V3), U2.49 (3V3), U3.1 (VDD); also elsewhere on the board
+5V: U2.33 (VIN); also elsewhere on the board
/Output Stage/DAC-CLOCK: U2.25 (18_A4_SDA0); also elsewhere on the board
/Output Stage/DAC-D0: U2.2 (0_RX1_CRX2_CS1); also elsewhere on the board
/Output Stage/DAC-D1: U2.3 (1_TX1_CTX2_MISO1); also elsewhere on the board
/Output Stage/DAC-D2: U2.4 (2_OUT2); also elsewhere on the board
/Output Stage/DAC-D3: U2.5 (3_LRCLK2); also elsewhere on the board
/Output Stage/DAC-D4: U2.6 (4_BCLK2); also elsewhere on the board
/Output Stage/DAC-D5: U2.7 (5_IN2); also elsewhere on the board
/Output Stage/DAC-D6: U2.8 (6_OUT1D); also elsewhere on the board
/Output Stage/DAC-D7: U2.9 (7_RX2_OUT1A); also elsewhere on the board
/Output Stage/DAC-D8: U2.10 (8_TX2_IN1); also elsewhere on the board
/Output Stage/DAC-D9: U2.11 (9_OUT1C); also elsewhere on the board
/Output Stage/DAC-D10: U2.21 (14_A0_TX3_SPDIF_OUT); also elsewhere on the board
/Output Stage/DAC-D11: U2.22 (15_A1_RX3_SPDIF_IN); also elsewhere on the board
/Output Stage/DAC-D12: U2.23 (16_A2_RX4_SCL1); also elsewhere on the board
/Output Stage/DAC-D13: U2.24 (17_A3_TX4_SDA1); also elsewhere on the board
/Overcurrent Protection/OCControl: U2.36 (25_A11_RX6_SDA2); also elsewhere on the board
/Overcurrent Protection/OCStatus: U2.37 (26_A12_MOSI1); also elsewhere on the board
/Teensy/ADC-SHUNT: R9.1, R35.1; also elsewhere on the board
/Teensy/TempSense: U2.35 (24_A10_TX6_SCL2); also elsewhere on the board
GND: C15.1, C16.1, U2.1 (GND), U2.17 (GND), U2.32 (GND), U2.47 (GND), U3.2 (GND); also elsewhere on the board
unnamed: R9.2, U2.38 (27_A13_SCK1)
unnamed: R35.2, U3.3 (AIN)
unnamed: U2.12 (10_CS_MQSR), U3.6 (~CS)
unnamed: U2.14 (12_MISO_MQSL), U3.5 (SDO)
unnamed: U2.20 (13_SCK_CRX1_LED), U3.4 (SCLK)

Parts:
C7, C8, C17, C19, C20: 100nF; C_0603_1608Metric
C18: DNM; C_0603_1608Metric
R10: 3.84k; R_0603_1608Metric
R11, R12: 25R; R_0603_1608Metric
R13, R14: 500R; R_0603_1608Metric
R15: 750R; R_0603_1608Metric
R18: 1k; R_0603_1608Metric
R19: 130k; R_0603_1608Metric
R20: 422k; R_0603_1608Metric
R21: 50k; R_0603_1608Metric
U4: AD9744; TSSOP-28_4.4x9.7mm_P0.65mm
U5, U6: THS3091; SOIC-8_3.9x4.9mm_P1.27mm
U7: LM285M-ADJ; SOIC-8_3.9x4.9mm_P1.27mm

Connections:
+3V3: C7.2, C8.2, U4.24 (AVDD), U4.27 (DVDD); also elsewhere on the board
+9V: C19.2, C20.2, U5.7 (Vs+), U6.7 (Vs+); also elsewhere on the board
+12V: R21.1; also elsewhere on the board
/Output Stage/DAC-CLOCK: U4.28 (CLK); also elsewhere on the board
/Output Stage/DAC-D0: U4.14 (D0); also elsewhere on the board
/Output Stage/DAC-D1: U4.13 (D1); also elsewhere on the board
/Output Stage/DAC-D2: U4.12 (D2); also elsewhere on the board
/Output Stage/DAC-D3: U4.11 (D3); also elsewhere on the board
/Output Stage/DAC-D4: U4.10 (D4); also elsewhere on the board
/Output Stage/DAC-D5: U4.9 (D5); also elsewhere on the board
/Output Stage/DAC-D6: U4.8 (D6); also elsewhere on the board
/Output Stage/DAC-D7: U4.7 (D7); also elsewhere on the board
/Output Stage/DAC-D8: U4.6 (D8); also elsewhere on the board
/Output Stage/DAC-D9: U4.5 (D9); also elsewhere on the board
/Output Stage/DAC-D10: U4.4 (D10); also elsewhere on the board
/Output Stage/DAC-D11: U4.3 (D11); also elsewhere on the board
/Output Stage/DAC-D12: U4.2 (D12); also elsewhere on the board
/Output Stage/DAC-D13: U4.1 (D13); also elsewhere on the board
/Output Stage/MOSFET-OUT: U6.2 (Vin-), U6.6 (Vout); also elsewhere on the board
GND: C7.1, C8.1, C17.1, C19.1, C20.1, R10.1, R11.1, R12.1, R20.2, U4.16 (REFLO), U4.20 (AGND), U4.25 (MODE), U4.26 (DGND), U5.4 (Vs-), U6.4 (Vs-), U7.4 (A); also elsewhere on the board
unnamed: C17.2, U4.17 (REFIO)
unnamed: C18.1, R11.2, R14.1, U4.21 (IOUTB)
unnamed: C18.2, R12.2, R13.1, U4.22 (IOUTA)
unnamed: R10.2, U4.18 (FS_ADJ)
unnamed: R13.2, R15.1, U5.2 (Vin-)
unnamed: R14.2, R18.1, U5.3 (Vin+)
unnamed: R15.2, U5.6 (Vout), U6.3 (Vin+)
unnamed: R18.2, R19.1, R21.2, U7.8 (K)
unnamed: R19.2, R20.1, U7.5 (FB)

Notes on the sheet:
1.92k: 10mA 3.84k: 20mA
Inspired by: https://www.analog.com/media/en/training-seminars/tutorials/MT-019.pdf#page=6 Figure 4
Vout = 5.25V
0-20mA: 0V-0.5V
20-0mA: 0.5V-0V
Amplifier stage converts the current output of the DAC to +5.25V +- 0.75V -> 4.5-6V (MOSFET IRFP4568)
Optional follower Opamp to increase current output of the amplifier stage from 250mA to 500mA max

Parts:
C2: 2.2uF; C_0603_1608Metric
C3, C5, C23: 22uF; C_1206_3216Metric
C4: 1000pF; C_0603_1608Metric
C21: 10uF; C_0805_2012Metric
C22: 10nF; C_0603_1608Metric
C25: 10uF 25V; C_0603_1608Metric
C26: 10nF 16V; C_0603_1608Metric
C27: 22uF 16V; C_0805_2012Metric
D1: CD1206-S01575; D_1206_3216Metric
D2, D4: CRS08; D_SOD-123F
D3: 1N4148W; D_SOD-123
D5: BZX84C4V3; D_SOT-23_ANK
D7: MBR0520; D_SOD-123
J6: 694106301002; BarrelJack_Wuerth_6941xx301002
L1: 4.7uH 1.2A; L_Taiyo-Yuden_NR-40xx; MPN NR4018T4R7M
L2, L3, L4: 22uH 1.4A; L_Taiyo-Yuden_NR-50xx; MPN NRS5040T220MMGKV
R16: 16.83k 1%; R_0603_1608Metric
R17, R24, R27: 10k 1%; R_0603_1608Metric
R22: 10k; R_0603_1608Metric
R23: 52k3; R_0603_1608Metric
R25: 100k; R_0603_1608Metric
R26: 102k 1%; R_0603_1608Metric
U8, U10: LM2734Y; TSOT-23-6
U9: LM2611xMF; SOT-23-5

Connections:
+5V: C23.1, D1.2 (A), L1.1, R23.1; also elsewhere on the board
+9V: C27.1, D5.1 (K), L2.1, R26.1; also elsewhere on the board
+12V: C3.2, C21.1, C25.1, J6.1, L3.2, R22.1, R25.1, U8.5 (VIN), U9.4 (~SHDN), U9.5 (VIN), U10.5 (VIN); also elsewhere on the board
-3V3: C4.2, C5.2, L4.1, R16.1; also elsewhere on the board
GND: C3.1, C5.1, C21.2, C23.2, C25.2, C27.2, D2.2 (A), D4.2 (A), D7.1 (K), J6.2, R17.2, R24.2, R27.2, U8.2 (GND), U9.2 (GND), U10.2 (GND); also elsewhere on the board
unnamed: C2.1, L3.1, U9.1 (SW)
unnamed: C2.2, D7.2 (A), L4.2
unnamed: C4.1, R16.2, R17.1, U9.3 (NFB)
unnamed: C22.1, D1.1 (K), U8.1 (BOOST)
unnamed: C22.2, D2.1 (K), L1.2, U8.6 (SW)
unnamed: C26.1, D3.1 (K), U10.1 (BOOST)
unnamed: C26.2, D4.1 (K), L2.2, U10.6 (SW)
unnamed: D3.2 (A), D5.2 (A)
unnamed: R22.2, U8.4 (EN)
unnamed: R23.2, R24.1, U8.3 (FB)
unnamed: R25.2, U10.4 (EN)
unnamed: R26.2, R27.1, U10.3 (FB)

Parts:
C28, C29, C30: 100nF; C_0603_1608Metric
D6: GREEN; LED_0603_1608Metric; MPN LTST-C191KGKT
D8: RED; LED_0603_1608Metric; MPN LTST-C190KRKT
Q3: BSS138; SOT-23
R28, R33, R34: 56K; R_0603_1608Metric
R29: 50K; R_0603_1608Metric
R30: 10K; R_0603_1608Metric
R31, R36: 1k; R_0603_1608Metric
R32: 166R; R_0603_1608Metric
RV1: 10K; Potentiometer_Bourns_3314G_Vertical; MPN 3314G-1-103E
SW1: TL3305A; SW_SPST_TL3305A
U11: LM285D-1.2; SOIC-8_3.9x4.9mm_P1.27mm
U12: 74LVC2G04; SOT-23-6_Handsoldering
U13: SN74LVC1G08DBVR; SOT-23-5_HandSoldering
U14: TC75S57FU(TE85L,F); SOT-353_SC-70-5
U15: 74LVC2G02; SSOP-8_2.95x2.8mm_P0.65mm
U16: TC4452; SOIC-8_3.9x4.9mm_P1.27mm

Connections:
+5V: C29.2, C30.1, R28.2, R34.2, SW1.1, U12.5 (VCC), U13.5 (VCC), U14.5 (Vdd), U15.8 (VCC), U16.1 (Vdd), U16.8 (Vdd); also elsewhere on the board
/Overcurrent Protection/OCControl: Q3.1 (G), R34.1; also elsewhere on the board
/Overcurrent Protection/OCMosfet: U16.6 (OUTPUT), U16.7 (OUTPUT); also elsewhere on the board
/Overcurrent Protection/OCSense: U14.3 (IN+); also elsewhere on the board
/Overcurrent Protection/OCStatus: Q3.3 (D), R33.1; also elsewhere on the board
/Overcurrent Protection/RESET': U13.4, U15.1
/Overcurrent Protection/SET: U12.1, U14.4 (OUT), U15.5
/Overcurrent Protection/Vref: C28.2, RV1.2, U14.1 (IN-)
GND: C28.1, C29.1, C30.2, D6.1 (K), D8.1 (K), Q3.2 (S), R30.1, RV1.3, U11.4 (A), U12.2 (GND), U13.3 (GND), U14.2 (Vss), U15.4 (GND), U16.4 (GND), U16.5 (GND); also elsewhere on the board
unnamed: D6.2 (A), R31.1
unnamed: D8.2 (A), R36.1
unnamed: R28.1, R29.2, U11.8 (K)
unnamed: R29.1, RV1.1
unnamed: R30.2, SW1.2, U13.2
unnamed: R31.2, R32.2, U12.4
unnamed: R32.1, R33.2, U16.2 (INPUT)
unnamed: R36.2, U12.3, U15.6, U15.7
unnamed: U12.6, U13.1
unnamed: U15.2, U15.3

Notes on the sheet:
Overcurrent Comparation Circuit
SET=1, IF Vref<Vi
Reset Logic Circuit
RS-Latch
Potentiometer for setting Imax
Mosfer Driver Stage
MCU Control

Board: 4 copper layers, 90.0 x 80.0 mm, 102 parts (1 on the bottom side), 75 nets.

## Commit log

2019-06-16 inital commit
2019-06-16 initial commit of schematics - work in progress
2019-06-16 custom library added
2019-06-17 output amplifier stage finished+THS3091 added to library
2019-06-17 power supplies added
2019-06-18 added dissipation Mosfet, cleaned up Main sheet
2019-06-18 cleaned up power supplies
2019-06-18 cleanup main sheet+added temperature measurement
2019-06-18 error check on schematic done
2019-06-18 footprint for M4 screw terminal added
2019-06-18 footprint for M4 screw terminal added to schematic
2019-09-19 added Overcurrent protection subsheet
2020-12-04 STM32 replaced by Teensy
    STM32 replaced by Teensy. OPA2354 added as amplifier frontend. Tina-Spice simulation file for amplifier frontend added.
2020-12-04 external ADC added
2020-12-17 project import to kicad 5.1.
2020-12-17 fixed file name. used kicad default gitignore
2020-12-17 fixed no connect DRC error
2020-12-17 removed labels from power connections. powr conn already global
2020-12-17 fixed resistor values for the 9V supply
2020-12-17 improved +5V supply visibility
2020-12-17 removed old -v2 files
2020-12-18 fixed -3V supply
2021-01-11 changed -3V3 power supply
2021-01-11 fixed output amp biasing
2021-01-11 removed redundant resistor
2021-01-12 changed the OC logic
2021-01-12 annotated sch
2021-01-14 fixed overcurrent circuit logic
2021-01-14 ERC check on the schematics
2021-01-14 added footprints to components
2021-01-22 added footprints to missing parts. did rough placement
2021-01-28 swapped current sensing opamps for better routing
2021-01-29 finished placement. started routing
2021-02-05 finished pcb
2021-02-18 changed heatsink
2021-02-18 generated gerbers
2021-02-18 generated sch pdf and component pos files
2021-02-19 added readme and license
2021-02-19 fix markup
2021-02-26 moved MOSFET to the middle, removed heatsink
2021-05-06 added DAC interface unit test
2021-05-06 adding simple DAC write function
2021-05-06 fixed compiler error
2021-05-16 added ADC read functionality for the built in ADC
2021-05-29 added ext ADC interface test
2021-05-29 fixed bit shifting for ADS7883
2021-06-05 fixed fast digital write
2021-06-05 refactor main application
